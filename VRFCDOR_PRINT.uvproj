# Keil uVision project VRFCDOR_PRINT.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51RD2 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF)  XRAM(0-0x6FF) CLOCK(33000000) MODP2
  output: VRFCDOR_PRINT_101 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\vrfcdor_impresora
  group Source Group 1
    ./: main.c Clock.c delay.c eeprom.c io_sensores.c monitor.c num_serie.c pantallas.c prog.c pto_paralelo.c tibbo.c uart.c Accescan.c verprint.c
